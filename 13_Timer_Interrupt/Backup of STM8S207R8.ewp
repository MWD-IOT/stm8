# IAR project Backup of STM8S207R8.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: FWlib\inc; User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S207R8.hex
  ILINK.IlinkOutputFile: STM8S207R8.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    FWlib/src/: stm8s_gpio.c stm8s_tim1.c
  group User
    User/: main.c stm8s_it.c

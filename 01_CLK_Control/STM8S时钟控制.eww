<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STM8S&#x65F6;&#x949F;&#x63A7;&#x5236;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


